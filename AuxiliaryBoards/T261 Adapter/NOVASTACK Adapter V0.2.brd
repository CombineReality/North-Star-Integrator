# Repository CombineReality/North-Star-Integrator

File README.md:

The Integrator is our custom-built USB hub system originally created for the CombineReality Project North Star Deck X. The Integrator cuts down the use of cables and adds customizable buttons to the headset with the following components & features:

    USB-C hub, two USB 3.1 ribbon connectors, and one USB 2.0 ribbon connector
    3GB on-board flash drive (only works when connected to a USB 3.0 host)
    Arduino-compatible microcontroller, featuring a Qwiic connector that can be used to connect additional sensors like an IMU, as well as HID buttons that can emulate keyboard    keys. A button breakout board is included, and the microcontroller is preflashed with firmware that maps the buttons to the default ergonomics adjustment keys. (Eye relief, eye position, and IPD)
    Also allows for manual power reset of sensor USB ports via a GPIO pin.
    A fan, the speed of which is controlled by the Arduino-compatible microcontroller.
    A thermistor for a more intelligent fan speed control
    A ribbon connector that lets the Arduino on the hub relay commands and debug output to and from the serial UART of the display driver board
    Ribbon adapter board for Intel® RealSense™ T261 embedded 6-DOF module (ribbon cable included)
    Ribbon adapter board for Leap Motion Controller (ribbon cable included)
    
Uses a modified version of the lilyPadUSB-caterina Arduino bootloader
Bootloader can be found here: https://github.com/CombineReality/ArduinoCore-avr

## EAGLE design AuxiliaryBoards/T261 Adapter/NOVASTACK Adapter V0.2.brd

Parts:
D4: ESD5Z6.0T1G; SOD523
J1: FPC-0.5-12PFPC-0.5-12P; FPC-0.5-12P
J2: 20709-034E-01; IPEX_20709-034E-01

Connections:
GND: D4.+, J1.1, J1.4, J1.7, J1.10, J2.5, J2.11, J2.17, J2.23, J2.26, J2.29, J2.32, J2.37, J2.38
USB2_N: J1.9, J2.15
USB2_P: J1.8, J2.13
USB3RX_N: J1.6, J2.3
USB3RX_P: J1.5, J2.1
USB3TX_N: J1.3, J2.9
USB3TX_P: J1.2, J2.7
VBUS3: D4.-, J1.11, J1.12, J2.35, J2.36

Board: 2 copper layers, 13.0 x 13.0 mm, 3 parts (0 on the bottom side), 8 nets.

## EAGLE design PCB/NorthStar_Hub_V0.3.1/North Star Hub Ver0.3.1.brd

Parts:
C1, C21: 20pF ±5% 50V; C0402
C2, C25: 1uF ±10% 10V; C0402
C5, C6, C7, C8, C43, C48, C69, C70: 100nF ±10% 10V; C0201
C9, C56: 4.7uF ±10% 10V; C0603
C10, C13, C33, C34, C35, C36, C37, C57, C59, C60, C61, C62, C63, C64, C65, C67, C68, C84: 100nF ±10% 10V; C0402
C11, C58: 56pF ±5% 50V; C0402
C12, C49, C66, C102, C103: 10uF ±10% 10V; C0603
C14, C29: 22uF ±20% 10V; C0805
C51: NA/100nF ±10% 10V; C0402
D1, D2, D5: TPD4E05U06DQ; USON-10_L2.5-W1.0-P0.50-BL
D4: ESD5Z6.0T1G; SOD523
IC1: GL3520-OS322; QFN40P800X800X80-65N
L1, L10: SMNR4012-2R2MT; L4012
L5, L6: BLM18EG221SN1D; L0603
R1, R8: 10K ±1%; R0402
R2: 47K ±1%; R0402
R3: 1M ±1%; R0402
R4: 680R ±1%; R0402
R5: 0R ±1%; R0805
R6, R9, R14, R39: 100K ±1%; R0402
R10, R11: NA/10K ±1%; R0402
R12: 470K ±1%; R0402
R13: 107K ±1%; R0402
R16, R18, R19: 200K ±1%; R0402
R20: 909K ±1%; R0402
R34: 51K ±1%; R0402
U1: AT25DF512C-MAHN-T; SOIC8-6.0
U2: HD3SS3220IRNHR; RNH0030A
U4, U5: SY8089; SOT23-5
USBC1: TYPEC-105450-0101105450-0101_USB-C-SMD_TYPE-C-USB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; USB-C-SMD_TYPE-C-USB-18
X4: 25MHZ; 4P-SMD-2X1.6MM

Connections:
+1V2: C11.2, C12.2, C13.2, C14.2, C59.1, C60.1, C61.1, C102.1, IC1.39 (DVDD12_1), IC1.56 (DVDD12_2), IC1.62 (DVDD12_3), L1.2, L6.2, R6.1
+3V3: C49.1, C51.2, C58.2, C62.2, C66.2, C67.1, C68.1, C84.2, IC1.40 (DVDD_1), IC1.54 (DVDD_2), IC1.63 (V33), L5.2, L10.2, R8.2, R10.1, R11.2, R12.1, R14.2, R16.2, U1.8 (VCC), U2.8 (VCC33); also elsewhere on the board
AV12: C33.1, C34.1, C35.1, C36.1, C37.1, C103.1, IC1.10 (VP12_2), IC1.16 (VP12_4), IC1.22 (VP12_6), IC1.28 (VP12_8), IC1.34 (VP12_10), L6.1
AV33: C63.1, C64.1, C65.1, IC1.45 (AVDD_1), IC1.48 (AVDD_2), IC1.51 (AVDD_3), L5.1
BUS: D4.-, R5.1, USBC1.A4 (VBUS), USBC1.A9 (VBUS), USBC1.B4 (VBUS), USBC1.B9 (VBUS)
CC1: D5.4 (D2+), D5.7 (NC), U2.2 (CC1), USBC1.A5 (CC1)
CC2: D5.5 (D2-), D5.6 (NC), U2.1 (CC2), USBC1.B5 (CC2)
CRX1_N: D1.2 (D1-), D1.9 (NC), U2.15 (RX1P), USBC1.B10 (SSRXN1)
CRX1_P: D1.1 (D1+), D1.10 (NC), U2.14 (RX1N), USBC1.B11 (SSRXP1)
CRX2_N: D2.1 (D1+), D2.10 (NC), U2.18 (RX2N), USBC1.A10 (SSRXN2)
CRX2_P: D2.2 (D1-), D2.9 (NC), U2.19 (RX2P), USBC1.A11 (SSRXP2)
CSBU1: USBC1.A8 (SBU1)
CSBU2: USBC1.B8 (SBU2)
CTX1_N: C5.1, D1.5 (D2-), D1.6 (NC), USBC1.A3 (SSTXN1)
CTX1_P: C6.1, D1.4 (D2+), D1.7 (NC), USBC1.A2 (SSTXP1)
CTX2_N: C7.1, D2.4 (D2+), D2.7 (NC), USBC1.B3 (SSTXN2)
CTX2_P: C8.1, D2.5 (D2-), D2.6 (NC), USBC1.B2 (SSTXP2)
DIR: R16.1, U2.11 (DIR)
DS1RX_N: IC1.15 (RXP_DS1); also elsewhere on the board
DS1RX_P: IC1.14 (RXN_DS1); also elsewhere on the board
DS1TXE_N: C48.2, IC1.13 (TXP_DS1)
DS1TXE_P: C43.2, IC1.12 (TXN_DS1)
DS1TX_N: C48.1; also elsewhere on the board
DS1TX_P: C43.1; also elsewhere on the board
DS1_USB2_N: IC1.43 (DM1); also elsewhere on the board
DS1_USB2_P: IC1.44 (DP1); also elsewhere on the board
DS2_USB2_N: IC1.46 (DM2); also elsewhere on the board
DS2_USB2_P: IC1.47 (DP2); also elsewhere on the board
DS3RX_N: IC1.26 (RXN_DS3); also elsewhere on the board
DS3RX_P: IC1.27 (RXP_DS3); also elsewhere on the board
DS3TX_N: IC1.24 (TXN_DS3); also elsewhere on the board
DS3TX_P: IC1.25 (TXP_DS3); also elsewhere on the board
DS3_USB2_N: IC1.49 (DM3); also elsewhere on the board
DS3_USB2_P: IC1.50 (DP3); also elsewhere on the board
DS4_USB2_N: IC1.52 (DM4); also elsewhere on the board
DS4_USB2_P: IC1.53 (DP4); also elsewhere on the board
D_UP_N: D5.1 (D1+), D5.10 (NC), IC1.41 (DM0), USBC1.A7 (DN1), USBC1.B7 (DN2)
D_UP_P: D5.2 (D1-), D5.9 (NC), IC1.42 (DP0), USBC1.A6 (DP1), USBC1.B6 (DP2)
GND: C1.2, C2.1, C9.1, C10.1, C12.1, C13.1, C14.1, C21.2, C25.2, C29.2, C33.2, C34.2, C35.2, C36.2, C37.2, C49.2, C51.1, C56.1, C57.1, C59.2, C60.2, C61.2, C62.1, C63.2, C64.2, C65.2, C66.1, C67.2, C68.2, C84.1, C102.2, C103.2, D1.3 (GND), D1.8 (GND), D2.3 (GND), D2.8 (GND), D4.+, D5.3 (GND), D5.8 (GND), IC1.65 (EP), R2.2, R4.1, R9.2, R13.2, R39.1, U1.4 (GND), U2.4 (PORT), U2.12 (EN_MUX_N), U2.13 (GND_2), U2.28 (GND), U2.29 (EN_CC_N), U2.31 (PAD), U4.2 (GND), U5.2 (GND), USBC1.0, USBC1.0-1 (0), USBC1.0-2 (0), USBC1.0-3 (0), USBC1.0-4 (0), USBC1.0-5 (0), USBC1.0-6 (0), USBC1.0-7 (0), USBC1.0-8 (0), USBC1.0-9 (0), USBC1.1 (0), USBC1.2 (0), USBC1.A1 (GND), USBC1.A12 (GND), USBC1.B1 (GND), USBC1.B12 (GND), X4.1 (1NC), X4.3 (3NC); also elsewhere on the board
unnamed: C1.1, IC1.3 (X1), R3.1, X4.4
unnamed: C21.1, IC1.4 (X2), R3.2, X4.2
unnamed: IC1.60 (PSELF), R8.1
unnamed: C58.1, R12.2, R13.1, U5.5 (FB)
unnamed: L10.1, U5.3 (LX)
unnamed: C11.1, R6.2, R9.1, U4.5 (FB)
unnamed: IC1.1 (RTERM), R4.2
unnamed: L1.1, U4.3 (LX)
unnamed: R20.1, U2.5 (VBUS_DET)
unnamed: C2.2, IC1.38 (VBUS), R34.1, R39.2
unnamed: R10.2, U1.3 (!WP!/IO2)
unnamed: R11.1, U1.7 (!HOLD!/IO3)
OUT1: R18.1, U2.25 (SDA_OUT1)
OUT2: R19.1, U2.26 (SCL_OUT2)
PGANG: IC1.55 (PGANG), R14.1
RESETJ: C25.1, IC1.61 (RESETJ), R1.2, R2.1
RX_UP_N: IC1.8 (RXN_UP), U2.10 (RXN)
RX_UP_P: IC1.9 (RXP_UP), U2.9 (RXP)
SPI_CK: IC1.35 (P_SPI_CK), U1.6 (CLK)
SPI_CZ: IC1.36 (P_SPI_CZ), U1.1 (!CS)
SPI_DI: IC1.59 (P_SPI_DI), U1.2 (DO/IO1)
SPI_DO: IC1.58 (P_SPI_DO), U1.5 (DI/IO0)
TX1_N: C5.2, U2.17 (TX1P)
TX1_P: C6.2, U2.16 (TX1N)
TX2_N: C7.2, U2.20 (TX2N)
TX2_P: C8.2, U2.21 (TX2P)
TXUP_N: C69.2, IC1.6 (TXN_UP)
TXUP_P: C70.2, IC1.7 (TXP_UP)
TX_N: C69.1, U2.7 (TXN)
TX_P: C70.1, U2.6 (TXP)
USB3_DS2RX_N: IC1.20 (RXN_DS2); also elsewhere on the board
USB3_DS2RX_P: IC1.21 (RXP_DS2); also elsewhere on the board
USB3_DS2TXE_N: IC1.18 (TXN_DS2); also elsewhere on the board
USB3_DS2TXE_P: IC1.19 (TXP_DS2); also elsewhere on the board
VBUS: C9.2, C10.2, C29.1, C56.2, C57.2, R1.1, R5.2, R18.2, R19.2, R20.2, R34.2, U2.30 (VDD5), U4.1 (EN), U4.4 (IN), U5.1 (EN), U5.4 (IN); also elsewhere on the board

Notes on the sheet:
USB 3.0 HUB
1.修改INT中断为PE6

Parts:
C40, C50, C73, C74, C83: 2.2uF ±10% 10V; C0402
C41, C42: 100nF ±10% 10V; C0201
C52, C72, C79, C80, C97: 100nF ±10% 10V; C0402
C53, C54, C55: 22uF ±20% 10V; C0603
C71, C75, C78, C81, C82, C99: 1uF ±10% 10V; C0402
C76, C77: 12pF ±10% 50V; C0402
D3: BLUE; 0402_LED
H1: THGBMNG5D1LBAIL; BGA153C50P14X14_11.5X13
L9: BLM18EG221SN1D; L0603
R17, R35: 10K ±1%; R0402
R21: 0R ±1%; R0402
R22: 680R ±1%; R0402
R23: 2K ±1%; R0402
R24: 47R ±1%; R0402
R25: 51K ±1%; R0402
R26: 1M ±1%; R0402
U3: GL3224E; TQFN48_7MM
U8: TPS2065C; SOT23-5
X3: 25MHZ; 4P-SMD-2X1.6MM

Connections:
!FLT3: R17.2, U8.3 (!FLT); also elsewhere on the board
+3V3: R17.1, R35.1; also elsewhere on the board
CLK-2: R24.1, U3.29 (S2CK_M2D0)
CMD-2: H1.M5 (CMD), U3.30 (S2CM_M2D2)
DAT0-1: H1.B3 (DAT4), U3.38 (S1D0_M1D1)
DAT0-2: H1.A3 (DAT0), U3.28 (S2D0_M2D1)
DAT1-1: H1.B4 (DAT5), U3.37 (S1D1_M1BS)
DAT1-2: H1.A4 (DAT1), U3.27 (S2D1_M2BS)
DAT2-1: H1.B5 (DAT6), U3.42 (S1D2_M1CK)
DAT2-2: H1.A5 (DAT2), U3.32 (S2D2_M2CK)
DAT3-1: H1.B6 (DAT7), U3.41 (S1D3_M1D3)
DAT3-2: H1.B2 (DAT3), U3.31 (S2D3_M2D3)
DS1RX_N: C41.1; also elsewhere on the board
DS1RX_P: C42.1; also elsewhere on the board
DS1TX_N: U3.10 (RXN); also elsewhere on the board
DS1TX_P: U3.11 (RXP); also elsewhere on the board
DS1_RX_N: C41.2, U3.7 (TXN)
DS1_RX_P: C42.2, U3.8 (TXP)
DVDD12: C75.2, C83.2, U3.9 (AVDD12), U3.26 (DVDD12)
DVDD33: C50.2, C73.2, C78.2, C79.2, C80.2, C99.2, H1.E6 (VCC_1), H1.F5 (VCC_2), H1.J10 (VCC_3), H1.K9 (VCC_4), U3.6 (AVDD33), U3.15 (AVDD33), U3.23 (S1M1_VCC), U3.25 (DVDD33), U3.34 (DVDD33), U3.44 (DVDD33)
EMMC_RST-2: C71.2, H1.K5 (RST__N), R25.2, U3.36 (SD2_CDZ)
EN3: R35.2, U8.4 (EN/!EN); also elsewhere on the board
GND: C40.1, C50.1, C52.2, C53.1, C54.1, C55.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.2, C77.2, C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C97.1, C99.1, D3.2 (-), H1.A6 (VSS_1), H1.C4 (VSSQ_1), H1.E7 (VSS_2), H1.G5 (VSS_3), H1.H10 (VSS_4), H1.J5 (VSS_5), H1.K8 (VSS_6), H1.N2 (VSSQ_2), H1.N5 (VSSQ_3), H1.P4 (VSSQ_4), H1.P6 (VSSQ_5), R21.1, R22.1, U3.3 (GND), U3.12 (GND), U3.35 (MS2_INS/SD2_WP), U3.THERMAL, U8.2 (GND), X3.1 (1NC), X3.3 (3NC); also elsewhere on the board
unnamed: H1.M6 (CLK), R24.2
unnamed: C72.2, H1.C2 (VDDI)
unnamed: C53.2, C54.2, C55.2, L9.1, U8.1 (OUT)
unnamed: R23.1, U3.21 (LED)
unnamed: D3.1 (+), R23.2
unnamed: R21.2, U3.1 (SD1_CDZ)
unnamed: R22.2, U3.16 (RTERM)
VBUS: C97.2, U8.5 (IN); also elsewhere on the board
VBUS3: C40.2, C52.1, L9.2, U3.22 (VBUS)
VCCQ: C74.2, C81.2, C82.2, H1.C6 (VCCQ_1), H1.M4 (VCCQ_2), H1.P3 (VCCQ_3), H1.P5 (VCCQ_4), R25.1, U3.33 (VUHS_2), U3.43 (VUHS_1)
X1: C77.1, R26.2, U3.13 (X1), X3.2
X2: C76.1, R26.1, U3.14 (X2), X3.4

Notes on the sheet:
Pin 6
Pin 33 44
Pin 43
Pin 33
Pin 9
Close to GL3224E
Mass Storage

Parts:
C30, C89: 1uF ±10% 10V; C0402
C31, C85: 22pF ±5% 50V; C0402
C88, C90, C91, C92, C93, C94, C95: 100nF ±10% 10V; C0402
D6: BLUE; 0402_LED
IC2: ATMEGA32U4-MUR; QFN50P700X700X100-45N
J2: HEADER-1P-32; 1P-60/32MIL
J6: SM04B-SRSS-TB
J10: NA; 2X3P-2.54-65/35MIL
K1: SKRKAEE020
R15, R27, R30: 4.7K ±1%; R0402
R28, R29: 22R ±1%; R0402
R31: 220R ±1%; R0402
R32: 2K ±1%; R0402
X1: 16MHZ; 4P-SMD-3.2X2.5

Connections:
!FLT1: IC2.27 (PD7_(T0/OC4D/ADC10)); also elsewhere on the board
!FLT2: IC2.25 (PD4_(ICP1/ADC8)); also elsewhere on the board
!FLT3: IC2.36 (PF7_(ADC7/TDI)); also elsewhere on the board
+3V3: C91.1, C92.1, C93.1, C94.1, IC2.14 (VCC_1), IC2.24 (AVCC_1), IC2.34 (VCC_2), IC2.44 (AVCC_2), J6.2, J10.6, R15.1, R27.1, R30.2; also elsewhere on the board
AREF: C88.1, IC2.42 (AREF)
DS1_USB2_N: R28.1; also elsewhere on the board
DS1_USB2_P: R29.1; also elsewhere on the board
D_N: IC2.3 (D-), R28.2
D_P: IC2.4 (D+), R29.2
EN1: IC2.28 (PB4_(PCINT4/ADC11)); also elsewhere on the board
EN2: IC2.26 (PD6_(T1/!OC4D!/ADC9)); also elsewhere on the board
EN3: IC2.31 (PC6_(OC3A/!OC4A)); also elsewhere on the board
FAN_PWM: IC2.30 (PB6_(PCINT6/OC1B/OC4B/ADC13)); also elsewhere on the board
GND: C30.2, C31.2, C85.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, D6.2 (-), IC2.5 (UGND), IC2.15 (GND_1), IC2.23 (GND_2), IC2.35 (GND_3), IC2.43 (GND_4), IC2.45 (GND_5), J6.1, J10.4, K1.2, X1.1 (1NC), X1.3 (3NC); also elsewhere on the board
INT: IC2.1 ((INT.6/AIN0)_PE6), J2.P$1
LED: IC2.32 (PC7_(ICP3/CLK0/OC4A)), R32.1
MISO: IC2.11 ((PDO/PCINT3/MISO)_PB3), J10.1
MOSI: IC2.10 ((PDI/PCINT2/MOSI)_PB2), J10.5
unnamed: C30.1, IC2.6 (UCAP)
unnamed: K1.1, R31.2
unnamed: D6.1 (+), R32.2
RESET: C95.1, IC2.13 (!RESET), J10.3, R30.1, R31.1
SCK: IC2.9 ((PCINT1/SCLK)_PB1), J10.2
SCL: IC2.18 ((OC0B/SCL/INT0)_PD0), J6.4, R15.2
SDA: IC2.19 ((SDA/INT1)_PD1), J6.3, R27.2
VBUS6: C89.1, C90.1, IC2.2 (UVCC), IC2.7 (VBUS); also elsewhere on the board
XTAL1: C31.1, IC2.17 (XTAL1), X1.2
XTAL2: C85.1, IC2.16 (XTAL2), X1.4

Notes on the sheet:
ATmega32U4

Parts:
C3, C4, C15, C16: 100nF ±10% 10V; C0201
C17, C19, C22, C24, C44, C86, C96, C101: 100nF ±10% 10V; C0402
C18, C20, C23, C26, C27, C28, C32, C38, C39, C45, C46, C47: 22uF ±20% 10V; C0603
C87, C98: 2.2uF ±10% 10V; C0402
C100: 10uF ±10% 10V; C0603
D7: PMEG2010AEB,115; SOD323
J1: FH34SRJ-6S-0.5SH(50); FH34RJ-6S
J3, J9: FH34SRJ-12S-0.5SH(50); FPC-0.5-12P
J4: XH-2AW; XH-02-90
J5: 53398-02
L2, L3, L4, L7, L8: BLM18EG221SN1D; L0603
Q1: CJ2301 S1; SOT23
Q2: DTC143ZUA; SOT323
R7, R37: 3.6M ±1%; R0402
R33, R40: 10K ±1%; R0402
R36: 100K ±1%; R0402
R38, R41: 0R ±1%; R0402
U6, U7: TPS2065C; SOT23-5

Connections:
!FLT1: R33.2, U6.3 (!FLT); also elsewhere on the board
!FLT2: R40.2, U7.3 (!FLT); also elsewhere on the board
+3V3: R7.1, R33.1, R37.2, R40.1; also elsewhere on the board
DS2_USB2_N: J3.4; also elsewhere on the board
DS2_USB2_P: J3.5; also elsewhere on the board
DS3RX_N: J9.10; also elsewhere on the board
DS3RX_P: J9.11; also elsewhere on the board
DS3TXE_N: C3.2, J9.7
DS3TXE_P: C4.2, J9.8
DS3TX_N: C3.1; also elsewhere on the board
DS3TX_P: C4.1; also elsewhere on the board
DS3_USB2_N: J9.4; also elsewhere on the board
DS3_USB2_P: J9.5; also elsewhere on the board
DS4_USB2_N: J1.4; also elsewhere on the board
DS4_USB2_P: J1.3; also elsewhere on the board
EN1: R38.1, U6.4 (EN/!EN); also elsewhere on the board
EN2: R41.2, U7.4 (EN/!EN); also elsewhere on the board
FAN_PWM: Q2.1 (INPUT); also elsewhere on the board
GND: C17.2, C18.1, C19.2, C20.1, C22.2, C23.1, C24.2, C26.1, C27.1, C28.1, C32.1, C38.1, C39.1, C44.2, C45.1, C46.1, C47.1, C86.1, C87.1, C96.1, C98.1, C100.1, C101.2, D7.+ (A), J1.1, J1.2, J3.3, J3.6, J3.9, J3.12, J4.1, J5.1, J9.3, J9.6, J9.9, J9.12, Q2.2 (E), U6.2 (GND), U7.2 (GND); also elsewhere on the board
unnamed: C98.2, R7.2, R41.1
unnamed: Q1.1 (G), Q2.3 (C), R36.1
unnamed: C26.2, C27.2, C28.2, L2.1, U6.1 (OUT)
unnamed: C87.2, R37.1, R38.2
unnamed: C32.2, C38.2, C39.2, L4.1, U7.1 (OUT)
unnamed: C100.2, D7.- (C), J5.2, Q1.3 (D)
USB3TX_N: C16.2, J3.7
USB3TX_P: C15.2, J3.8
USB3_DS2RX_N: J3.10; also elsewhere on the board
USB3_DS2RX_P: J3.11; also elsewhere on the board
USB3_DS2TXE_N: C16.1; also elsewhere on the board
USB3_DS2TXE_P: C15.1; also elsewhere on the board
VBUS: C18.2, C20.2, C23.2, C45.2, C46.2, C47.2, C86.2, C96.2, C101.1, L3.1, L7.1, L8.1, Q1.2 (S), R36.2, U6.5 (IN), U7.5 (IN); also elsewhere on the board
VBUS1: C19.1, J9.1, J9.2, L4.2
VBUS2: C24.1, J3.1, J3.2, L2.2
VBUS4: C22.1, J1.5, J1.6, L7.2
VBUS5: C44.1, J4.2, L8.2
VBUS6: C17.1, L3.2; also elsewhere on the board

Notes on the sheet:
FPC for Leap Motion Adapter
FPC for NOVASTACK Adapter
FPC forATmega32u4
FPC for Free USB3
1A Limit for USB3 port2
1A Limit for USB3 port3
Power connector for SuperCapactor
Connector
